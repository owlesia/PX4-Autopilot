## src/examples/battery_soc/Kconfig
```kconfig
menuconfig EXAMPLES_BATTERY_SOC
	bool "battery_soc"
	default n
	---help---
		Enable support for battery_soc
```
